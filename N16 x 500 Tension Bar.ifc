Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: Project Number
Time: 2022-05-16T09:02:06
Written by: ODA IFC SDK 22.8
Made in: 22.1.21.13 - Exporter 22.1.21.13 - Alternate UI 22.1.21.13

# IfcProject, Project Number
LongName: Widgets; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: RamsetReid; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Widgets; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: RamsetReid; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Widgets; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: N16 x 500 Tension Bar:N16, N16 x 500 Tension Bar:N16:252872
In: Level 1
Type - Material: <Unnamed>, Galvanized
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - L: 500 mm; Th: 16 mm; W: 500 mm
Type - Identity Data - Model: N16; Type Name: N16
Type - Materials and Finishes - Material: Galvanised Steel
Type - Other - Category: Generic Models; Family Name: N16 x 500 Tension Bar
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: N16
Pset_EnvironmentalImpactIndicators - Reference: N16
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Schedule Level: Level 1
Dimensions - Area: 0.0291132 m2; Volume: 0.000185277 m3
Other - Family: N16 x 500 Tension Bar; Family and Type: N16 x 500 Tension Bar: N16; Type: N16; Type Id: 252844
Phasing - Phase Created: New Construction
