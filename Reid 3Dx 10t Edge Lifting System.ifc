Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: Project Number
Time: 2022-05-16T09:00:02
Written by: ODA IFC SDK 22.8
Made in: 22.1.21.13 - Exporter 22.1.21.13 - Alternate UI 22.1.21.13

# IfcProject, Project Number
LongName: Widgets; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: RamsetReid; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Widgets; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: RamsetReid; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Widgets; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: Reid 3Dx 10t Edge Lifting System:3DX10N, Reid 3Dx 10t Edge Lifting System:3DX10N:251156
In: Level 1
Type - Material: Galvanized
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - L: 225 mm; Th: 30 mm; W: 75 mm
Type - Identity Data - Model: 3DX10N; Type Name: 3DX10N
Type - Materials and Finishes - Material: Galvanised Steel
Type - Other - Category: Generic Models; Family Name: Reid 3Dx 10t Edge Lifting System
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: 3DX10N
Pset_EnvironmentalImpactIndicators - Reference: 3DX10N
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Schedule Level: Level 1
Dimensions - Area: 0.0370129 m2; Volume: 0.0003763 m3
Other - Family: Reid 3Dx 10t Edge Lifting System; Family and Type: Reid 3Dx 10t Edge Lifting System: 3DX10N; Type: 3DX10N; Type Id: 251126
Phasing - Phase Created: New Construction
